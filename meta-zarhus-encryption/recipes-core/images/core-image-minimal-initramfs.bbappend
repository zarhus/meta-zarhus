INITRAMFS_SCRIPTS = " \
    initramfs-framework-base \
    initramfs-module-udev \
    initramfs-module-encrypt-decrypt \
"
