FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://enable-tpm.cfg"
