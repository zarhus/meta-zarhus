require encryption.inc
