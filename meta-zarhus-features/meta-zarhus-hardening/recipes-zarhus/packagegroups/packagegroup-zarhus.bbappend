RDEPENDS:${PN}-system:append = " sudo"
