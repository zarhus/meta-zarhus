IMAGE_INSTALL:append = " \
    packagegroup-zarhus-webkit \
    packagegroup-zarhus-net \
"

SYSTEMD_DEFAULT_TARGET = "graphical.target"
