RDEPENDS:${PN}-system:append:odroid-h4 = " efibootmgr zarhus-efi-setup"
