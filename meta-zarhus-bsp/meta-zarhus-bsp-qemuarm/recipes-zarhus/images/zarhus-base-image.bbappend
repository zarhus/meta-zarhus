require qemu.inc
