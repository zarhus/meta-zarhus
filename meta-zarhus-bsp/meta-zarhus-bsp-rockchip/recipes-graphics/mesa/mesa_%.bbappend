PACKAGECONFIG:append:rk3566 = " kmsro panfrost"
