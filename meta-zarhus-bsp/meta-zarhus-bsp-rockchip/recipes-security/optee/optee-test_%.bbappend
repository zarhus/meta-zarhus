COMPATIBLE_MACHINE:rk3566 = "rk3566"
