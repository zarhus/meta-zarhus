MACHINE_OPTEE_OS_TADEVKIT_REQUIRE:rk3566 = "optee-os-rk3566.inc"

require ${MACHINE_OPTEE_OS_TADEVKIT_REQUIRE}
