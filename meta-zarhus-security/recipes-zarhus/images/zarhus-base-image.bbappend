IMAGE_INSTALL:append = " \
    packagegroup-zarhus-security \
"
