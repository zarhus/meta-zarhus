MACHINE_REQUIRE:rk3566 = "rockchip-rkbin-rk3566.inc"

require ${MACHINE_REQUIRE}
